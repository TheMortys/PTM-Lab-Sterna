LED BIT P1.0
LED1 BIT P1.1
LED2 BIT P1.2
LED3 BIT P1.3
LED4 BIT P1.4
LED5 BIT P1.5
LED6 BIT P1.6
LED7 BIT P1.7

ORG 0
	
	START:
	MOV R7, #100
	MOV A, R7
	CLR LED
	CLR LED1
	CLR LED2
	CLR LED3
	SETB LED4
	SETB LED5
	SETB LED6
	SETB LED7
	LCALL DELAY
	CLR LED
	CLR LED1
	CLR LED2
	CLR LED3
	SETB LED4
	SETB LED5
	SETB LED6
	SETB LED7
	LCALL DELAY
	CLR LED
	CLR LED1
	CLR LED2
	CLR LED3
	SETB LED4
	SETB LED5
	SETB LED6
	SETB LED7
	LCALL DELAY
	SJMP START
	
;======================	
   ;DELAY R7 x 10 ms
;======================	
	DELAY:
		MOV R0, A
	DELAY1:
		MOV R1, #5
	DELAY2:
		MOV R2, #250
	DELAY3:
		NOP
		NOP
		DJNZ R2, DELAY3
		DJNZ R1, DELAY2
		DJNZ R0, DELAY1
		RET
END